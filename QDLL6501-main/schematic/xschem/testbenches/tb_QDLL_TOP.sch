v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
B 2 830 -230 1630 170 {flags=graph
y1=1.5
y2=3.5
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=1.0865e-07
x2=1.0565e-07
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
linewidth_mult=0.5
divx=20
color="7 4 21 1"
node="inpad1
inpad2
outpad1
outpad2"}
B 2 830 190 1630 590 {flags=graph
y1=-0.4198089
y2=1.6533911
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="7 4 21 1"
node="in1
in2
out1
out2"
linewidth_mult=0.5
divx=20
hilight_wave=0
x1=1.0865e-07
x2=1.0565e-07}
N -680 370 -680 380 {
lab=IO_vdd}
N -740 370 -740 380 {
lab=IO_iovdd}
N -800 370 -800 380 {
lab=IO_vss}
N -860 370 -860 380 {
lab=IO_iovss}
N -250 250 240 250 {lab=IO_iovdd}
N 210 -20 270 -20 {lab=IO_vdd}
N 220 -30 270 -30 {lab=IO_vss}
N 230 -70 270 -70 {lab=IO_iovss}
N 240 -80 270 -80 {lab=IO_iovdd}
N 210 60 270 60 {lab=IO_vdd}
N 220 50 270 50 {lab=IO_vss}
N 220 -30 220 50 {lab=IO_vss}
N 230 10 270 10 {lab=IO_iovss}
N 230 -70 230 10 {lab=IO_iovss}
N 240 0 270 0 {lab=IO_iovdd}
N 240 -50 240 0 {lab=IO_iovdd}
N -250 -80 -250 0 {lab=IO_iovdd}
N 240 -80 240 -50 {lab=IO_iovdd}
N 230 10 230 30 {lab=IO_iovss}
N 510 -80 510 -50 {lab=IO_iovdd}
N 240 -50 510 -50 {lab=IO_iovdd}
N 510 -10 510 30 {lab=IO_iovss}
N 230 30 510 30 {lab=IO_iovss}
N -590 0 -590 30 {lab=IO_vss}
N -590 -90 -590 -50 {lab=IO_vdd}
N -290 -80 -250 -80 {lab=IO_iovdd}
N -250 -160 -250 -80 {lab=IO_iovdd}
N -290 -70 -240 -70 {lab=IO_iovss}
N -240 -150 -240 -70 {lab=IO_iovss}
N -290 -30 -230 -30 {lab=IO_vss}
N -290 -20 -220 -20 {lab=IO_vdd}
N -220 -50 -220 -20 {lab=IO_vdd}
N -290 0 -250 0 {lab=IO_iovdd}
N -290 10 -240 10 {lab=IO_iovss}
N -240 -70 -240 10 {lab=IO_iovss}
N -290 50 -230 50 {lab=IO_vss}
N -230 30 -230 50 {lab=IO_vss}
N -290 60 -220 60 {lab=IO_vdd}
N -220 -20 -220 60 {lab=IO_vdd}
N -540 30 -230 30 {lab=IO_vss}
N -630 30 -590 30 {lab=IO_vss}
N -230 -30 -230 30 {lab=IO_vss}
N -630 -50 -590 -50 {lab=IO_vdd}
N -540 -50 -220 -50 {lab=IO_vdd}
N -220 140 -220 220 {lab=IO_vdd}
N -220 220 210 220 {lab=IO_vdd}
N -220 -100 -220 -50 {lab=IO_vdd}
N -290 -110 -230 -110 {lab=IO_vss}
N -230 -110 -230 -30 {lab=IO_vss}
N -230 -230 -230 -110 {lab=IO_vss}
N -290 -150 -240 -150 {lab=IO_iovss}
N -240 -240 -240 -150 {lab=IO_iovss}
N -290 -160 -250 -160 {lab=IO_iovdd}
N -250 -250 -250 -160 {lab=IO_iovdd}
N -230 -230 220 -230 {lab=IO_vss}
N -590 -130 -530 -130 {lab=inpad1}
N -630 -130 -590 -130 {lab=inpad1}
N -290 -100 -220 -100 {lab=IO_vdd}
N -220 -220 -220 -100 {lab=IO_vdd}
N -450 430 -430 430 {lab=GND}
N -430 430 -430 440 {lab=GND}
N -530 430 -510 430 {lab=sub!}
N -530 430 -530 440 {lab=sub!}
N 240 140 240 250 {lab=IO_iovdd}
N -240 240 230 240 {lab=IO_iovss}
N -1020 80 -1020 100 {lab=GND}
N -540 -50 -540 -40 {lab=IO_vdd}
N -590 -50 -540 -50 {lab=IO_vdd}
N -540 20 -540 30 {lab=IO_vss}
N -590 30 -540 30 {lab=IO_vss}
N 510 30 570 30 {lab=IO_iovss}
N 240 -100 240 -80 {lab=IO_iovdd}
N 230 -110 230 -70 {lab=IO_iovss}
N 220 -150 220 -30 {lab=IO_vss}
N 210 -160 210 -20 {lab=IO_vdd}
N -240 -240 230 -240 {lab=IO_iovss}
N -250 -250 240 -250 {lab=IO_iovdd}
N 210 -160 270 -160 {lab=IO_vdd}
N 220 -150 270 -150 {lab=IO_vss}
N 240 -100 270 -100 {lab=IO_iovdd}
N 240 -250 240 -100 {lab=IO_iovdd}
N 230 -110 270 -110 {lab=IO_iovss}
N 230 -240 230 -110 {lab=IO_iovss}
N 210 -220 210 -160 {lab=IO_vdd}
N 220 -230 220 -150 {lab=IO_vss}
N 510 -130 540 -130 {lab=outpad1}
N 540 -130 570 -130 {lab=outpad1}
N -590 110 -530 110 {lab=inpad2}
N -290 80 -250 80 {lab=IO_iovdd}
N -250 0 -250 80 {lab=IO_iovdd}
N -290 90 -240 90 {lab=IO_iovss}
N -240 10 -240 90 {lab=IO_iovss}
N -290 130 -230 130 {lab=IO_vss}
N -230 50 -230 130 {lab=IO_vss}
N -290 140 -220 140 {lab=IO_vdd}
N -220 60 -220 140 {lab=IO_vdd}
N -250 80 -250 250 {lab=IO_iovdd}
N -240 90 -240 240 {lab=IO_iovss}
N -230 130 -230 230 {lab=IO_vss}
N 210 80 210 220 {lab=IO_vdd}
N 220 90 220 230 {lab=IO_vss}
N 230 130 230 240 {lab=IO_iovss}
N -620 370 -620 380 {
lab=VDD}
N -920 370 -920 380 {
lab=VSS}
N -930 50 -930 100 {lab=GND}
N -10 -220 210 -220 {lab=IO_vdd}
N 220 90 270 90 {lab=IO_vss}
N 240 140 270 140 {lab=IO_iovdd}
N 230 130 270 130 {lab=IO_iovss}
N 210 80 270 80 {lab=IO_vdd}
N 220 50 220 90 {lab=IO_vss}
N 240 0 240 140 {lab=IO_iovdd}
N 230 30 230 130 {lab=IO_iovss}
N 210 60 210 80 {lab=IO_vdd}
N 210 -20 210 60 {lab=IO_vdd}
N -10 230 220 230 {lab=IO_vss}
N 540 -200 540 -130 {lab=outpad1}
N 540 110 540 190 {lab=outpad2}
N 540 110 570 110 {lab=outpad2}
N 510 -50 570 -50 {lab=IO_iovdd}
N 510 110 540 110 {lab=outpad2}
N -590 110 -590 170 {lab=inpad2}
N -630 110 -590 110 {lab=inpad2}
N -590 -190 -590 -130 {lab=inpad1}
N -290 -130 -180 -130 {lab=in1}
N -180 -130 -180 -40 {lab=in1}
N -290 110 -180 110 {lab=in2}
N -180 40 -180 110 {lab=in2}
N -180 -40 -160 -40 {lab=in1}
N -180 40 -160 40 {lab=in2}
N 140 40 160 40 {lab=out2}
N 160 40 160 110 {lab=out2}
N 160 110 270 110 {lab=out2}
N 140 -40 160 -40 {lab=out1}
N 160 -130 160 -40 {lab=out1}
N 160 -130 270 -130 {lab=out1}
N -1020 -30 -1020 20 {lab=#net1}
N -930 -30 -930 -10 {lab=#net2}
N -10 -220 -10 -100 {lab=IO_vdd}
N -220 -220 -10 -220 {lab=IO_vdd}
N -10 100 -10 230 {lab=IO_vss}
N -230 230 -10 230 {lab=IO_vss}
N 50 100 50 140 {lab=CP}
N 50 100 60 100 {lab=CP}
N -1020 -240 -1020 -90 {lab=inpad1}
N -930 -250 -930 -90 {lab=inpad2}
C {vsource.sym} -680 410 0 0 {name=V1 value=\{vdd\}}
C {gnd.sym} -680 440 0 0 {name=l3 lab=GND}
C {lab_pin.sym} -680 370 1 0 {name=p7 sig_type=std_logic lab=IO_vdd}
C {vsource.sym} -740 410 0 0 {name=V2 value=3.3
}
C {gnd.sym} -740 440 0 0 {name=l4 lab=GND}
C {lab_pin.sym} -740 370 1 0 {name=p8 sig_type=std_logic lab=IO_iovdd}
C {vsource.sym} -800 410 0 0 {name=V3 value=0 savecurrent=false}
C {gnd.sym} -800 440 0 0 {name=l5 lab=GND}
C {lab_pin.sym} -800 370 1 0 {name=p9 sig_type=std_logic lab=IO_vss}
C {vsource.sym} -860 410 0 0 {name=V4 value=0 savecurrent=false}
C {gnd.sym} -860 440 0 0 {name=l6 lab=GND}
C {lab_pin.sym} -860 370 1 0 {name=p10 sig_type=std_logic lab=IO_iovss}
C {devices/code_shown.sym} -1130 -530 0 0 {name=MODEL only_toplevel=true
format="tcleval( @value )"
value="
.lib cornerMOSlv.lib mos_tt
*.lib cornerMOSlv.lib mos_ss
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.include diodes.lib
.include sg13g2_bondpad.lib
.include $::env(PDK_ROOT)/$::env(PDK)/libs.ref/sg13g2_stdcell/spice/sg13g2_stdcell.spice
"}
C {lab_pin.sym} 510 -80 2 0 {name=p3 sig_type=std_logic lab=IO_iovdd}
C {lab_pin.sym} 510 -10 2 0 {name=p4 sig_type=std_logic lab=IO_iovss}
C {lab_pin.sym} -590 -90 0 1 {name=p5 sig_type=std_logic lab=IO_vdd}
C {lab_pin.sym} -590 0 2 0 {name=p6 sig_type=std_logic lab=IO_vss}
C {sg13g2_IOPadIOVdd.sym} 390 -50 0 0 {name=x1}
C {sg13g2_IOPadIOVss.sym} 390 30 0 0 {name=x3}
C {sg13g2_IOPadVSS.sym} -410 30 0 1 {name=x2}
C {sg13g2_IOPadVdd.sym} -410 -50 0 1 {name=x4}
C {sg13g2_pr/bondpad.sym} 610 30 1 0 {name=X6
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} 610 -50 1 0 {name=X7
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} -670 -50 3 1 {name=X8
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} -670 30 3 1 {name=X9
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {devices/launcher.sym} 890 -410 0 0 {name=h5
descr="load waves Ctrl + left click" 
tclcommand="xschem raw_read $netlist_dir/transient.raw tran"
}
C {sg13g2_IOPadAnalog.sym} -410 -130 0 1 {name=x13}
C {sg13g2_pr/bondpad.sym} -670 -130 3 1 {name=X14
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {gnd.sym} -1020 100 0 0 {name=l7 lab=GND}
C {lab_pin.sym} -1020 -240 1 0 {name=p11 sig_type=std_logic lab=inpad1}
C {lab_pin.sym} -590 -190 2 0 {name=p1 sig_type=std_logic lab=inpad1}
C {sg13g2_pr/sub.sym} -530 440 0 0 {name=l8 lab=sub!}
C {gnd.sym} -430 440 0 0 {name=l11 lab=GND}
C {vsource.sym} -480 430 1 0 {name=V5 value=0 savecurrent=false}
C {sg13g2_pr/bondpad.sym} 610 -130 1 0 {name=X16
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 540 -200 2 0 {name=p13 sig_type=std_logic lab=outpad1}
C {vsource.sym} -1020 50 0 0 {name=Vin value="PULSE(0 \{vin\} 0 \{trf\} \{trf\} \{duty\} \{per\})"
}
C {res.sym} -1020 -60 2 0 {name=R4
value=50
footprint=1206
device=resistor
m=1}
C {code.sym} -160 -520 0 0 {name=TRANSIENT_TT only_toplevel=true
value="
.param temp=65 vdd=1.2 
.param per=4n duty=2n trf=20p delay=2n
.param vin=1.2 vd=\{vdd\}


.options method=gear reltol=1e-1 abstol=1e-1 vntol=1e-1
.control
 set color0 = white
 tran 20p 400n
 *v(inpad1) v(in1) v(inpad2) v(in2)
 plot v(inpad1) v(outpad1)  v(inpad2) v(outpad2) 
 plot v(CP)
 plot v(in1) v(in2) v(out1) v(out2)
 *plot v(out1) v(out2) v(outpad1) v(outpad2)
 write transient.raw
 wrdata tb_QDLL_TOP_TT.txt v(inpad1) v(inpad2) v(outpad1) v(outpad2)
.endc
"
}
C {sg13g2_IOPadAnalog.sym} 390 -130 2 1 {name=x5
}
C {sg13g2_IOPadAnalog.sym} -410 110 0 1 {name=x10
}
C {sg13g2_pr/bondpad.sym} -670 110 3 1 {name=X11
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {vsource.sym} -620 410 0 0 {name=V6 value=\{vdd\}}
C {gnd.sym} -620 440 0 0 {name=l2 lab=GND}
C {lab_pin.sym} -620 370 1 0 {name=p12 sig_type=std_logic lab=VDD}
C {vsource.sym} -920 410 0 0 {name=V7 value=0 savecurrent=false}
C {gnd.sym} -920 440 0 0 {name=l9 lab=GND}
C {lab_pin.sym} -920 370 1 0 {name=p14 sig_type=std_logic lab=VSS}
C {gnd.sym} -930 100 0 0 {name=l1 lab=GND}
C {lab_pin.sym} -930 -250 1 0 {name=p2 sig_type=std_logic lab=inpad2}
C {vsource.sym} -930 20 0 0 {name=Vin1 value="PULSE(0 \{vin\} \{delay\} \{trf\} \{trf\} \{duty\} \{per\})"
}
C {res.sym} -930 -60 2 0 {name=R1
value=50
footprint=1206
device=resistor
m=1}
C {sg13g2_pr/bondpad.sym} 610 110 1 0 {name=X15
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 540 190 2 0 {name=p15 sig_type=std_logic lab=outpad2}
C {sg13g2_IOPadAnalog.sym} 390 110 2 1 {name=x18
}
C {lab_pin.sym} -590 170 2 0 {name=p18 sig_type=std_logic lab=inpad2}
C {QDLL_TOP.sym} -10 0 0 0 {name=x12}
C {lab_pin.sym} -180 -130 2 0 {name=p16 sig_type=std_logic lab=in1}
C {lab_pin.sym} -180 110 2 0 {name=p17 sig_type=std_logic lab=in2}
C {lab_pin.sym} 160 110 0 0 {name=p19 sig_type=std_logic lab=out2}
C {lab_pin.sym} 160 -130 0 0 {name=p20 sig_type=std_logic lab=out1}
C {code.sym} 10 -520 0 0 {name=TRANSIENT_SS only_toplevel=true
value="
.param temp=125 vdd=1.08 
.param per=4n duty=2n trf=20p delay=2n
.param vin=1.08 vd=\{vdd\}


.options method=gear reltol=1e-1 abstol=1e-1 vntol=1e-1
.control
 tran 20p 120n
 * v(inpad1) v(in1) v(inpad2) v(in2)
 plot v(inpad1) v(inpad2) v(outpad1) v(outpad2)
 *plot v(in1) v(in2) v(out1) v(out2)
 *plot v(out1) v(out2) v(outpad1) v(outpad2)
 write transient.raw

 *wrdata tb_QDLL_TOP_SS.txt v(inpad1) v(inpad2) v(outpad1) v(outpad2)
.endc
"
spice_ignore=true}
C {code.sym} 170 -520 0 0 {name=TRANSIENT_FF only_toplevel=true
value="
.param temp=0 vdd=1.32
.param per=4n duty=2n trf=20p delay=2n
.param vin=1.32 vd=\{vdd\}


.options method=gear reltol=1e-1 abstol=1e-2 vntol=1e-2
.control
 tran 20p 80n
 * v(inpad1) v(in1) v(inpad2) v(in2)
 *plot v(inpad1) v(inpad2) v(outpad1) v(outpad2)
 *plot v(in1) v(in2) v(out1) v(out2)
 plot v(out1) v(out2) v(outpad1) v(outpad2)
 write transient.raw

 *wrdata tb_QDLL_TOP_FF.txt v(inpad1) v(inpad2) v(outpad1) v(outpad2)
.endc
"
spice_ignore=true}
C {code.sym} 330 -520 0 0 {name=PHASE_MEASR only_toplevel=true
value="
.param temp=65 vdd=1.2 
.param per=5n duty=2.5n  trf=250p delay=2.5n
.param vin=1.2 vd=\{vdd\}


.options method=gear reltol=1e-1 abstol=1e-1 vntol=1e-1
.control
 tran 20p 80n

   * ---- user settings ----
  let vlow  = 0
  let vhigh = 1.2
  let v50   = vlow + 0.5*(vhigh - vlow)

  let start_edge = 0     ; skip early edges (settling)
  let N = 1000             ; number of phase samples




  * ---- allocate vectors ----
  let tvec   = vector(N)
  let phivec = vector(N)

  let k = 0
  let i = start_edge

  while k < N
    * crossing times
    meas tran tin      WHEN v(inpad1)=v50  RISE=i
    meas tran tout     WHEN v(outpad1)=v50 RISE=i
    meas tran tin_next WHEN v(inpad1)=v50  RISE=(i+1)

    * delay + period
    let dt = tout - tin
    let T  = tin_next - tin

    * phase in degrees (per-cycle)
    let phi = 360*dt/T
    let phi = phi - 360*floor(phi/360)

    * store sample at time = tin
    let tvec[k]   = tin
    let phivec[k] = phi

    let k = k + 1
    let i = i + 1
  end

  * plot phase vs time (one point per cycle)
  plot phivec vs tvec
  plot v(inpad1) v(outpad1) 
  plot v(CP) 
.endc
"
spice_ignore=true}
C {lab_pin.sym} 50 140 0 0 {name=p21 sig_type=std_logic lab=CP
spice_ignore=short}
